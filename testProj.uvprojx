# Keil uVision project testProj.uvprojx, settings and files
target motorMonitorPlus (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: testProj
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\inc;.\CMIS;.\hal;.\menu;.\SRAM;.\selfTest;.;.\adc;.\zigbee;.\core;.\powerHal
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group main
    ./: projectDefines.h startup.s main_fw.c
  group hal
    ./hal/: led.h spiHal.c spiHal.h led.c timerHal.h timerHal.c gpioHal.c gpioHal.h uartHal.c uartHal.h
  group src
    ./Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_comp_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_cryp.c stm32l0xx_hal_cryp_ex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_firewall.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2s.c stm32l0xx_hal_irda.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_lcd.c stm32l0xx_hal_lptim.c stm32l0xx_hal_msp_template.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rng.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_smartcard.c stm32l0xx_hal_smartcard_ex.c stm32l0xx_hal_smbus.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_tsc.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_wwdg.c stm32l0xx_ll_adc.c stm32l0xx_ll_comp.c stm32l0xx_ll_crc.c stm32l0xx_ll_crs.c stm32l0xx_ll_dac.c stm32l0xx_ll_dma.c stm32l0xx_ll_exti.c stm32l0xx_ll_gpio.c stm32l0xx_ll_i2c.c stm32l0xx_ll_lptim.c stm32l0xx_ll_lpuart.c stm32l0xx_ll_pwr.c stm32l0xx_ll_rcc.c stm32l0xx_ll_rng.c stm32l0xx_ll_rtc.c stm32l0xx_ll_spi.c stm32l0xx_ll_tim.c stm32l0xx_ll_usart.c stm32l0xx_ll_utils.c
  group inc
    ./Inc/: stm32_assert_template.h stm32l0xx_hal.h stm32l0xx_hal_adc.h stm32l0xx_hal_adc_ex.h stm32l0xx_hal_comp.h stm32l0xx_hal_comp_ex.h stm32l0xx_hal_conf_template.h stm32l0xx_hal_cortex.h stm32l0xx_hal_crc.h stm32l0xx_hal_crc_ex.h stm32l0xx_hal_cryp.h stm32l0xx_hal_cryp_ex.h stm32l0xx_hal_dac.h stm32l0xx_hal_dac_ex.h stm32l0xx_hal_def.h stm32l0xx_hal_dma.h stm32l0xx_hal_firewall.h stm32l0xx_hal_flash.h stm32l0xx_hal_flash_ex.h stm32l0xx_hal_flash_ramfunc.h stm32l0xx_hal_gpio.h stm32l0xx_hal_gpio_ex.h stm32l0xx_hal_i2c.h stm32l0xx_hal_i2c_ex.h stm32l0xx_hal_i2s.h stm32l0xx_hal_irda.h stm32l0xx_hal_irda_ex.h stm32l0xx_hal_iwdg.h stm32l0xx_hal_lcd.h stm32l0xx_hal_lptim.h stm32l0xx_hal_lptim_ex.h stm32l0xx_hal_pcd.h stm32l0xx_hal_pcd_ex.h stm32l0xx_hal_pwr.h stm32l0xx_hal_pwr_ex.h stm32l0xx_hal_rcc.h stm32l0xx_hal_rcc_ex.h stm32l0xx_hal_rng.h stm32l0xx_hal_rtc.h stm32l0xx_hal_rtc_ex.h stm32l0xx_hal_smartcard.h stm32l0xx_hal_smartcard_ex.h stm32l0xx_hal_smbus.h stm32l0xx_hal_spi.h stm32l0xx_hal_tim.h stm32l0xx_hal_tim_ex.h stm32l0xx_hal_tsc.h stm32l0xx_hal_uart.h stm32l0xx_hal_uart_ex.h stm32l0xx_hal_usart.h stm32l0xx_hal_usart_ex.h stm32l0xx_hal_wwdg.h stm32l0xx_ll_adc.h stm32l0xx_ll_bus.h stm32l0xx_ll_comp.h stm32l0xx_ll_cortex.h stm32l0xx_ll_crc.h stm32l0xx_ll_crs.h stm32l0xx_ll_dac.h stm32l0xx_ll_dma.h stm32l0xx_ll_exti.h stm32l0xx_ll_gpio.h stm32l0xx_ll_i2c.h stm32l0xx_ll_iwdg.h stm32l0xx_ll_lptim.h stm32l0xx_ll_lpuart.h stm32l0xx_ll_pwr.h stm32l0xx_ll_rcc.h stm32l0xx_ll_rng.h stm32l0xx_ll_rtc.h stm32l0xx_ll_spi.h stm32l0xx_ll_system.h stm32l0xx_ll_tim.h stm32l0xx_ll_usart.h stm32l0xx_ll_utils.h stm32l0xx_ll_wwdg.h
  group CMIS
    ./CMIS/: core_cm0plus.h core_cmFunc.h core_cmInstr.h arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cm0.h core_cm3.h core_cm4.h core_cm7.h core_cmSimd.h core_sc000.h core_sc300.h
  group system
    ./system/: system_stm32l0xx.c
  group menu
    ./menu/: menu.c menu.h
  group SRAM
    ./SRAM/: MC23A1024.c MC23A1024.h
  group selfTest
    ./selfTest/: memorySelfTest.h memorySelfTest.c
  group ADC
    ./adc/: adc.c adc.h
  group zigbee
    ./zigbee/: zigbee.c zigbee.h
  group core
    ./core/: sampler.c sampler.h
  group powerHal
    ./powerHal/: ldo.c ldo.h
